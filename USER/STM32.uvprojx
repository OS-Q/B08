# Keil uVision project STM32.uvprojx, settings and files
target STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_F1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\USER;..\LIB\inc;..\LIB\src;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\BSP;..\BSP\gpio_init;..\BSP\delay;..\BSP\DMP;..\BSP\IOI2C;..\BSP\TIM;..\BSP\USART;..\BSP\rc522;..\uCOS-III\Ports;..\uCOS-III\Source;..\uCOS-III\CPU;..\uCOS-III\LIB;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c
  group BSP
    ../BSP/delay/: delay.c
    ../BSP/rc522/: rc522.c
    ../BSP/USART/: usart1.c usart2.c
    ../BSP/gpio_init/: gpio_init.c
    ../BSP/: timer2.c rtc_config.c spi_flash.c 24cxx.c xy_iic.c
  group LIB
    ../LIB/src/: stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group uCOS-III_Core
    ../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOS-III_Port
    ../uCOS-III/Ports/: os_cpu_c.c os_cpu_a.s
  group uCOS-III_CPU
    ../uCOS-III/CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group uCOS-III_LIB
    ../uCOS-III/LIB/: lib_math.c lib_mem.c lib_ascii.c lib_str.c lib_mem_a.asm
  group APP
    ../APP/: app.c os_app_hooks.c rc522_task.c uart2_task.c open_result_task.c led_task.c flash_task.c watch_dog.c
software components: CMSIS:CORE 5.0.1
